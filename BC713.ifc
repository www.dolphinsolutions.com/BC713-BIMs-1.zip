Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2019-03-11T15:25:17
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20140709_2115(x64) - Exporter 2014.0.2014.0709 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 11 15:25:17 2019 * Host: BIM-HP * Database: C:\Users\dcole\AppData\Local\Temp\{9F6B7354-CD0A-4723-BBB6-AB4BF7C87FF9}\ifc * Database version: 5507 * Database creation date: Mon Mar 11 15:25:16 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 11 15:25:16 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 11 15:25:16 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: P:\Fastrack\53721_DOLPHIN SOLUTIONS LIMITED\ADDITIONAL DRAWINGS 2019 BIM\IFC\BC713.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Symbol at End 2 Default: yes; Line Pattern: -3000010; Symbol at End 1 Default: no; Line Weight: 1

# IfcBuildingElementProxy: BC713 Dolphin Stainless Steel Soap Dispenser, BC713:BC713 Dolphin Stainless Steel Soap Dispenser:10211
In: Level 1
Material: Stainless Steel, Spout, Glass
Phasing - Phase Created: New Construction
Dimensions - Volume: 0.00206481 m3; Height: 158mm; Bulk fill: 1200ml; Width: 178mm; Projection: Body = 67mm & Soap Dispenser Spout = 62mm Total = 129mm
Constraints - Level: Level: Level 1; Host: Level : Level 1; Offset: 0 mm; Moves With Nearby Elements: no
Pset_ManufacturerTypeInformation - Manufacturer: Dolphin Solutions Ltd.
Pset_BuildingElementProxyCommon - Reference: BC713 Dolphin Stainless Steel Soap Dispenser
Identity Data - Address: Southpoint, Compass Park, Bodiam, Robertsbridge, TN32 5BS; Tel No.: +44 (0) 1424 202 224; Assembly Description: Other Plumbing Fixtures; Manufacturer: Dolphin Solutions Ltd.; Description: Stainless steel soap dispenser; Email: info@dolphinsolutions.co.uk; Assembly Code: D2010900; Model: BC713; URL: www.dolphinsolutions.co.uk; Fax No.: +44 (0) 1424 205 200
General - Product Page Link: https://www.dolphinsolutions.co.uk/product/stainless-steel-soap-dispenser-6/; Product Data: Stylish satin stainless steel soap dispenser. Non-drip, one-shot action. Durable, high quality stainless steel. Bulk fill 1200ml. Lackable. Concealed fixing. Uses Standard Liquid Hand Soap and most Anti Bacterial Soaps.
